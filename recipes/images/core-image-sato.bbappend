IMAGE_INSTALL += " pmd-demo"
